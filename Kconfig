## Kconfig
```kconfig
mainmenu "Drone tracker"

source "Kconfig.zephyr"

config TRACKER_PRODUCTION
    bool "Aplicar invariantes del firmware de produccion"
    default y
```
